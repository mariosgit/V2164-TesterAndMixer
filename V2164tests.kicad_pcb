# Repository mariosgit/V2164-TesterAndMixer

File README.md:

# V2164 Tester / Mixer

Simple board to test V2164 chips. Follows the application example in the SSM2164 datasheet.

Can also be used as a 2 channel stereo mixer.

| | |
|---|---|
|  |  |

## Status

Ok.

### v0.1 Test results

* It works ✅
* Pot direction reversed - CCW turns gain up 😒
* right side ouput label should be "3+4" 🤷‍♂️
* Resistor divider - one would be enouth

### v0.2 not tested / will not test / should be ok.

* twisted Pot directions
* changed right out label
* added version label

## Gimmics

For cleverness sake, chip adapters can be used.

With R1/R4 and R14/R15 the range of the pots can be limited.  **For testing u can just short these**.
In theory 0V is 0dB and then the gain factor is -33mV/dB with a max range of -120..+20 dB, that equals 3.96V=-120dB to -0.66V=+20dB.

Ask your favorite chat bot for a voltage divider fitting your needs.

    To design a voltage divider with three resistors in series between +12V and -12V that meets your specified voltage requirements, we'll follow these steps:

    ### Given:
    - **Supply voltages**: +12V (top) and -12V (bottom)
    - **Middle resistor (R₂)**: 10 kΩ
    - **Desired voltage at top of R₂ (V₂)**: +3.96V
    - **Desired voltage at bottom of R₂ (V₃)**: -0.66V

    bla bla bla...

    ### Final Resistor Values:
    - **Top resistor (R₁)**: **17.4 kΩ**
    - **Middle resistor (R₂)**: **10 kΩ** (given)
    - **Bottom resistor (R₃)**: **24.55 kΩ**

    ### Practical Considerations:
    - You may need to use standard resistor values close to the calculated ones (e.g., 17.4 kΩ ≈ 17.8 kΩ or 18 kΩ; 24.55 kΩ ≈ 24.9 kΩ or 25 kΩ). 
    - For higher precision, you can use a potentiometer or combine resistors in series/parallel.

Or use the experimental [falstad circuit](https://www.falstad.com/circuit/circuitjs.html?ctz=CQAgjCAMB0l3BWcMBMcUHYMGZIA4UA2ATmIxAUgpABZsKBTAWjDACgA3WvcYlbkHirDaVMPxEwEnAdjQCwfKMppiJyqWwBOIFAkKCqeg2Bo1lYIXG279u1bYNyRe+GwDujkM-Bnv8yA8vIV9zEMDPGh5FflNzGKg2AAdQw1SE+hEweBzk9KU4-ypMixy3T0KfKKLEir8Q6vC8ulilFu9IcxKxMuswDHNjVNxBhwhs+ChYSCQAJQYAZwBLBYAXAEMAOwBjBjYAcxAWEyVj+0kD2jkO83bsBHUIo7AT-mqEp5HeN+uPvPv+CgHADvA9vBpkL1msQTH4aDCvN1IWUgvDYYM7IVPmCgUY7LjaqD+CC7p1CaTbgihoEgA).

### BOM

| References | Value | Footprint | Quantity |
|---|---|---|---|
| C5, C6, C7, C8               | 560p | 603 | 4 |
| C2, C3                       | 220p (100p+) | 603 | 2 |
| R2, R3, R5, R6, R7, R8 | 33k | 603 | 6 |
| R10, R11, R12, R13, R16, R17 | 470 | 0603 | 6 |
| R1, R4, R14, R15             | 5k see notes | 603 | 4 |
| *R9*                         | 7.5k for class A or *open for class AB* | 603 | 1 |
| U1                           | SSI2164 | DIP-16 7.62mm or SO-16 + Adapter | 1 |
| U2                           | TL074 <br> or any such 4x OpAmp | DIP-14 7.62mm or SO/SOP/TSOP-14 + Adapter | 1 |
| RV1, RV2                     | 10k see notes | 9mm Potentiometer Vertical | 2 |

### Schematic

### Reference from DS

Also read the datasheet, just search for "V2164 pdf" or "SSM2164 pdf".

## KiCad design V2164tests.kicad_pcb

Parts:
C1, C4, C9, C10: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3: 220p; C_Disc_D4.3mm_W1.9mm_P5.00mm
C5, C6, C7, C8: 560p; C_Disc_D4.3mm_W1.9mm_P5.00mm
H1, H2: MountingHole_Pad; TestPoint_THTPad_D2.0mm_Drill1.0mm
J1, J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J3, J4: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
JP1, JP2: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1, R4, R14, R15: 5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R5, R6, R7, R8: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 7.5k for class A or DNP for class AB; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R11, R12, R13, R16, R17: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV2: 10k; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical
TP1: In1; TestPoint_Loop_D2.50mm_Drill1.0mm
TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP12, TP13, TP14, TP15: TestPoint; TestPoint_Loop_D2.50mm_Drill1.0mm
TP9: In3; TestPoint_Loop_D2.50mm_Drill1.0mm
TP10: In4; TestPoint_Loop_D2.50mm_Drill1.0mm
TP11: In2; TestPoint_Loop_D2.50mm_Drill1.0mm
U1: SSI2164; DIP-16_W7.62mm_LongPads
U2: TL074; DIP-14_W7.62mm_LongPads

Connections:
+12V: C9.2, C10.2, J2.1, J3.4, R1.2, R14.2, TP2.1, U1.16 (V+), U2.4 (V+)
-12V: C1.1, C4.1, J2.8, J4.4, R4.1, R9.2, R15.1, TP3.1, U1.9 (V-), U2.11 (V-)
/U01: C2.2, J3.1, R2.2, R17.1, U2.1
/U02: C2.1, J1.4, J1.5, J3.2, R2.1, U1.4 (I_OUT1), U1.5 (I_OUT2), U2.2 (-)
/U05: H1.1, J3.5, RV2.2, TP6.1, U2.5 (+)
/U06: J1.3, J2.3, J3.6, J3.7, U1.3 (VC1), U1.14 (VC4), U2.6 (-), U2.7
/U08: J1.6, J2.6, J4.6, J4.7, U1.6 (VC2), U1.11 (VC3), U2.8, U2.9 (-)
/U10: H2.1, J4.5, RV1.2, TP5.1, U2.10 (+)
/U13: C3.1, J2.4, J2.5, J4.2, R3.1, U1.12 (I_OUT3), U1.13 (I_OUT4), U2.13 (-)
/U14: C3.2, J4.1, R3.2, R16.1, U2.14
/V01: J1.1, R9.1, U1.1 (MODE)
/V02: J1.2, R5.2, R10.2, U1.2 (I_IN1)
/V07: J1.7, R6.2, R11.2, U1.7 (I_IN2)
/V10: J2.7, R7.2, R12.2, U1.10 (I_IN3)
/V15: J2.2, R8.2, R13.2, U1.15 (I_IN4)
GND: C1.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, J1.8, J3.3, J4.3, TP4.1, TP12.1, TP13.1, TP14.1, TP15.1, U1.8 (GND), U2.3 (+), U2.12 (+)
unnamed: C5.2, R13.1
unnamed: C6.2, R12.1
unnamed: C7.2, R11.1
unnamed: C8.2, R10.1
unnamed: JP1.1 (A), R6.1, TP11.1
unnamed: JP1.2 (B), R5.1, TP1.1
unnamed: JP2.1 (A), R8.1, TP10.1
unnamed: JP2.2 (B), R7.1, TP9.1
unnamed: R1.1, RV1.1
unnamed: R4.2, RV1.3
unnamed: R14.1, RV2.1
unnamed: R15.2, RV2.3
unnamed: R16.2, TP8.1
unnamed: R17.2, TP7.1

Notes on the sheet:
Stereo Mixer L 1 2 -> U2pin1 R 4 3 -> U2pin14 ^ ^ R R V V 2 1
Rin = Rfb = 33k -> unity gain the SSM2164 has a -33 mV/dB gain constant -> 30db / v ??? up to 20 dB gain ... -100 dB of attenuation. also -.66V ... 3.96V

Board: 2 copper layers, 33.0 x 80.0 mm, 54 parts (0 on the bottom side), 30 nets.

## Commit log

2025-07-10 ini commit
2025-07-10 More to README.
2025-07-31 fixes v0.2
2025-07-31 typos..
2025-07-31 status update
